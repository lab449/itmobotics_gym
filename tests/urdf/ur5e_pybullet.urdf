Commit message: CHange initial pose and action space

File: tests/urdf/ur5e_pybullet.urdf (robot description, URDF)
Before this commit: robot ur5e, 13 links, 12 joints
Joints:
- joint camera_link_joint: origin xyz=0.00 -0.08 0.0 rpy=-0.1 0.0 0.0 -> xyz=0.00 -0.08 0.0 rpy=-0.0 0.0 0.0
