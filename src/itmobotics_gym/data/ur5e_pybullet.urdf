Commit message: hotfix jacobi

File: src/itmobotics_gym/data/ur5e_pybullet.urdf (robot description, URDF)
Before this commit: robot ur5e, 13 links, 12 joints
Joints:
- joint base-base_link_fixed_joint: origin xyz=0 0 0 rpy=0 0 -3.14159265359 -> xyz=0 0 0 rpy=0 0 0
